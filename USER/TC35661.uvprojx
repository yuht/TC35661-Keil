# Keil uVision project TC35661.uvprojx, settings and files
target TC35661 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TC35661 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\stm32_usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\SYSH;..\HARDWARE\5110;..\bt_src;..\bt_src\drivers;..\bt_src\drivers\bluetooth;..\bt_src\drivers\fc;..\bt_src\tasks;..\bt_src\xlib;..\bt_src\xlib\core
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/5110/: 5110LCD.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/stm32_usart/: stm32_usart.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group bt_src
    ../bt_src/: common.h common.cpp
    ../bt_src/xlib/core/: usart.h usart.cpp
    ../bt_src/drivers/bluetooth/: pan1026.h pan1026.cpp pan1322.h pan1322.cpp bt.h bt.cpp
